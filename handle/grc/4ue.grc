options:
  parameters:
    generate_options: no_gui
    id: hello
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 23.04e6
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '4'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_1
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_1_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_1_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: zeromq_rep_sink_0
  id: zeromq_rep_sink
  parameters:
    address: ipc:///dev/shm/srsenb_rx
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_rep_sink_1
  id: zeromq_rep_sink
  parameters:
    address: ipc:///dev/shm/srsue1_rx
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_rep_sink_2
  id: zeromq_rep_sink
  parameters:
    address: ipc:///dev/shm/srsue2_rx
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_rep_sink_2_0
  id: zeromq_rep_sink
  parameters:
    address: ipc:///dev/shm/srsue3_rx
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_rep_sink_2_0_0
  id: zeromq_rep_sink
  parameters:
    address: ipc:///dev/shm/srsue4_rx
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_req_source_0
  id: zeromq_req_source
  parameters:
    address: ipc:///dev/shm/srsue1_tx
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_req_source_1
  id: zeromq_req_source
  parameters:
    address: ipc:///dev/shm/srsue2_tx
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_req_source_1_0
  id: zeromq_req_source
  parameters:
    address: ipc:///dev/shm/srsue3_tx
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_req_source_1_0_0
  id: zeromq_req_source
  parameters:
    address: ipc:///dev/shm/srsue4_tx
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_req_source_2
  id: zeromq_req_source
  parameters:
    address: ipc:///dev/shm/srsenb_tx
    timeout: '100'
    type: complex
  states: {}

connections:
- [blocks_add_xx_0, '0', zeromq_rep_sink_0, '0']
- [blocks_throttle_0, '0', zeromq_rep_sink_1, '0']
- [blocks_throttle_1, '0', zeromq_rep_sink_2, '0']
- [blocks_throttle_1_0, '0', zeromq_rep_sink_2_0, '0']
- [blocks_throttle_1_0_0, '0', zeromq_rep_sink_2_0_0, '0']
- [zeromq_req_source_0, '0', blocks_add_xx_0, '0']
- [zeromq_req_source_1, '0', blocks_add_xx_0, '1']
- [zeromq_req_source_1_0, '0', blocks_add_xx_0, '2']
- [zeromq_req_source_1_0_0, '0', blocks_add_xx_0, '3']
- [zeromq_req_source_2, '0', blocks_throttle_0, '0']
- [zeromq_req_source_2, '0', blocks_throttle_1, '0']
- [zeromq_req_source_2, '0', blocks_throttle_1_0, '0']
- [zeromq_req_source_2, '0', blocks_throttle_1_0_0, '0']

metadata:
  file_format: 1
